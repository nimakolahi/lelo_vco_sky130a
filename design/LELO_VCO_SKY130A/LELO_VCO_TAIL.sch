v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0 {name=p0 lab=VSS}
C {devices/iopin.sym} 0 20 0 0 {name=p1 lab=Vin}
C {devices/iopin.sym} 0 40 0 0 {name=p2 lab=net16}
C {devices/iopin.sym} 0 60 0 0 {name=p3 lab=net18}
