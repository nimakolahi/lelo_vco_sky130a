v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {cborder/border_s.sym} 520 0 0 0 {
user="wulff"
company="wulff"}
C {devices/ipin.sym} -120 -670 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} -120 -570 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} -120 -620 0 0 {name=p3 lab=PWRUP_1V8}
